# Repository allentsou/attiny85-headlight-toggle

File README.md:

# ATtiny85 機車大燈控制器（強光線組版）

用一顆 ATtiny85 自製的機車大燈控制器，功能仿照市售的「DSP 智能大燈模組」：平常近燈可以關掉，想開時把遠燈開關撥一下就能切換。燈的電流直接從電瓶供應（強光線組），原車開關只當訊號用。

已經做成洞洞板、實際裝在 LED 大燈的機車上使用。

**[互動佈線圖](https://allentsou.github.io/attiny85-headlight-toggle/hardware/perfboard.html)**：點線路可單獨標亮，附每個零件的孔位表。

作者的原型板（手工佈線，零件位置和上圖不同，電路相同）：

## 功能

- 發動後**近燈預設關**。
- 把把手撥到遠燈約 **2 秒**，遠燈會**熄一下**當提示；這時**馬上撥回近燈**，近燈就會「開／關」切換。
- 提示後超過 0.8 秒才撥回，視為正常使用遠燈，不切換。超車閃燈（按不到 2 秒）完全不受影響。
- 遠燈直接跟著開關走，沒有延遲。
- 開遠燈時會關掉近燈（程式裡 `LOW_WITH_HIGH` 可改成遠近同亮）。
- 熄火後控制器完全斷電，不吃電瓶。
- 看門狗：被雜訊干擾當機時 0.5 秒內自動重開，騎車中重開會保留近燈狀態。

### 狀態燈

| 狀態燈 | 意思 |
|---|---|
| 通電時閃 1 下 | 正常開機 |
| 通電時閃 3 下 | 上次被看門狗重啟過（曾受雜訊干擾） |
| 恆亮 / 不亮 | 近燈開 / 近燈關 |
| 快閃 | 遠燈提示後的確認時間，這時撥回近燈就會切換 |

## 運作原理

```
原車近燈線 ──1N5819──┐
原車遠燈線 ──1N5819──┴─ VIN ── TVS / 1000µF / 放電電阻 ── L7805 ── 5V ── ATtiny85
     │
     └─ 22k / 10k 分壓 + 5.1V 稽納 ── PB3（偵測遠燈開關）

ATtiny85 PB0 ── 1k ── SS8050 ── 4.7k ── IRF4905（P-MOS）── 遠燈
ATtiny85 PB4 ── 1k ── SS8050 ── 4.7k ── IRF4905（P-MOS）── 近燈
                                          ↑
                         電瓶+（經保險絲）接兩顆 MOS 的 S 腳
```

- **MCU 供電**：從原車近燈、遠燈線經二極體取電，所以熄火就斷電。
- **遠燈偵測**：用 ADC 讀電壓並加遲滯，9V 以上算開、6V 以下算關，中間維持原狀，避免下雨天開關漏電誤判。
- **驅動**：MCU 的 5V 不能直接控制接在 12V 的 P-MOS，所以用 SS8050 做轉換。MOS 是高側開關，燈的地線直接回車架。

## 檔案

| 路徑 | 內容 |
|---|---|
| [`firmware/headlight_toggle/`](firmware/headlight_toggle/headlight_toggle.ino) | Arduino 程式（ATTinyCore） |
| [`hardware/BOM.md`](hardware/BOM.md) | 零件清單 |
| [`hardware/perfboard.md`](hardware/perfboard.md) | 洞洞板佈線圖與每個零件的孔位 |
| [`hardware/perfboard.html`](https://allentsou.github.io/attiny85-headlight-toggle/hardware/perfboard.html) | 互動佈線圖（線上開啟，或下載後用瀏覽器開） |
| [`hardware/kicad/`](hardware/kicad/) | KiCad 10 原理圖、PCB（已送 JLCPCB 製作，尚未驗證）與 Gerber |
| [`docs/programming.md`](docs/programming.md) | 用 USBasp 燒錄的完整步驟，附燒錄座洞洞板佈局圖 |
| [`docs/troubleshooting.md`](docs/troubleshooting.md) | 實際遇過的問題和解法 |

## 製作步驟

1. 照 [零件清單](hardware/BOM.md) 備料。
2. 照 [洞洞板佈線](hardware/perfboard.md) 焊接。**C5（IC 旁的 104）和 R14（C1 旁的 2.2k 放電電阻）不能省**，少了這兩顆通電時偶爾會開機失敗。
3. 先不插晶片，接 12V 量 IC 座第 8 腳對第 4 腳要約 5V。
4. 照 [燒錄說明](docs/programming.md) 燒好 ATtiny85，插上 IC 座。
5. 在桌上接 12V 和負載測試：電瓶+ 和地線先接好不動，原車近燈線串一個撥動開關模擬鑰匙，原車遠燈線也接一個開關，反覆開關幾十次確認每次都正常開機、切換。
6. 裝上車。

## 裝車注意事項

- **保險絲**靠近電瓶正極裝。LED 大燈遠近燈全開約 2.5A，用 5A 保險絲即可。
- **原車大燈插頭不要剪**，用公母對插頭轉接。控制器故障時可以直接插回原廠線路。
- IRF4905 的金屬背板就是汲極（燈的輸出）。有裝散熱片且沒墊絕緣片的話，**散熱片帶電，不能碰到車架**或彼此碰到。
- 板子塗三防漆或裝盒防水，用束帶固定防震；晶片可以點一點熱熔膠固定在 IC 座上。
- 只適用**直流大燈**。老式交流大燈（發電線圈直供）要另外設計。
- 本作者的車是**內建驅動器的 LED 大燈**，遠燈模式時燈本身會連近燈一起點亮，這是燈的行為，不是控制器的問題。

## 免責聲明

- 台灣新車多為大燈常亮（AHO）設計，**夜間或隧道不開大燈會被取締**，也有安全疑慮。這個控制器建議只在白天或停車時關近燈。
- 改裝車輛電系有風險，請自行評估，作者不對任何損壞或事故負責。

## 授權

[MIT License](LICENSE)：程式、電路、PCB 和文件都可以自由使用、修改、商用，保留版權聲明即可。

## KiCad design hardware/kicad/headlight.kicad_pcb

File hardware/kicad/README.md:

# KiCad 原理圖與 PCB（KiCad 10）

用 KiCad 10 開 `headlight.kicad_pro`。原理圖、PCB 都在這個資料夾，零件符號與封裝隨專案附上（`headlight.kicad_sym`、`headlight.pretty/`），不用另外裝庫。

| 檔案 | 內容 |
|---|---|
| `headlight.kicad_sch` | 原理圖 |
| `headlight.kicad_pcb` | PCB（90 × 40 mm，雙層板，全插件） |
| `headlight.pdf` | 原理圖 PDF，沒裝 KiCad 也能看 |
| `gerber/headlight_rev7_jlcpcb.zip` | Gerber＋鑽孔檔，可直接上傳嘉立創（JLCPCB）等板廠 |

ERC、DRC（含原理圖與 PCB 一致性檢查）都是 0 錯誤。

> [!WARNING]
> **這片 PCB 已送嘉立創（JLCPCB）製作，還沒組裝驗證。** 作者目前裝在車上的是洞洞板版本（見 [perfboard.md](../perfboard.md)），電路相同，但 PCB 的佈線是另外畫的。板子到貨、實測後會更新這裡；在那之前想打板的話請自行承擔風險。

## PCB 版和洞洞板版的差異

電路相同，只有幾顆零件規格不同（[零件清單](../BOM.md) 是照洞洞板寫的）：

| 編號 | PCB 版（本資料夾） | 洞洞板版（BOM） | 說明 |
|---|---|---|---|
| U1 | 78L05（TO-92） | L7805CV（TO-220） | 控制器只吃幾 mA，兩種都可以 |
| C1 | 470µF 25V | 1000µF 25V | 兩種都夠 |
| TVS1 | P6KE18A（插件） | SMBJ18A（貼片） | 都是單向 18V，不要用 CA 雙向 |
| R14 | 3k | 2.2k | C1 放電電阻，2.2k～4.7k 都可以 |
| R15、J5 | 有 | 無 | 外接第二顆狀態燈（JST XH 2P），和板上 LED1 同時亮；不用可不焊 |
| J1、J2、J4 | 焊線孔 | 直接焊線 | J1 原車訊號輸入、J2 燈輸出、J4 電瓶 |

其他零件編號和 [零件清單](../BOM.md)、[洞洞板佈線](../perfboard.md) 一致。

## 看原理圖

- 有黑點的交叉才相連，沒黑點的交叉不相連。
- 接地符號全部相連；5V、BATT 箭頭同名的也相連。
- 線上的小字（SENSE、PB0…）是網路名稱，和 PCB 上的名稱一致。
- PWR_FLAG（菱形旗子）只是告訴 ERC 這裡有電源進來，不是零件。

Parts:
C1: 470uF 25V; CP_Radial_D10.0mm_P5.00mm
C2, C3, C4, C5: 104; C_Disc_D6.0mm_W2.5mm_P6.00mm
D1, D2: 1N5819; D_DO-41_SOD81_P10.16mm_Horizontal
IC1: ATtiny85-20PU; DIP-8_W7.62mm_Socket
J1: IN: LOW / HIGH / GND; SolderWire-0.75sqmm_1x03_P4.8mm_D1.25mm_OD2.3mm
J2: LAMP: HIGH / LOW / GND; SolderWire-0.75sqmm_1x03_P4.8mm_D1.25mm_OD2.3mm
J4: BATT: + / -; SolderWire-0.75sqmm_1x02_P4.8mm_D1.25mm_OD2.3mm
J5: EXT LED; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
LED1: 3mm; LED_D3.0mm
M1, M2: IRF4905; TO-220-3_Vertical
Q1, Q2: SS8050; TO-92_Inline_Wide
R1, R3, R5, R7, R10, R12: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: 22k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4, R9, R13, R15: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R6, R11: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R14: 3k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
TVS1: P6KE18A; D_DO-15_P10.16mm_Horizontal
U1: 78L05; TO-92_Inline_Wide
Z1: 1N4733A; D_DO-41_SOD81_P10.16mm_Horizontal

Connections:
5V: C3.2, C5.1, IC1.8 (VCC), J5.1, LED1.2 (A), R1.1, U1.1 (OUT)
/HIGH_OUT: J2.1, M1.2 (D)
/LED2_K: J5.2, R15.2
/LED_K: LED1.1 (K), R13.2
/LOW_OUT: J2.2, M2.2 (D)
/M1_G: M1.1 (G), R6.1, R7.1
/M2_G: M2.1 (G), R11.2, R12.1
/PB0: IC1.5 (PB0), R4.1
/PB1: IC1.6 (PB1), R13.1, R15.1
/PB4: IC1.3 (PB4), R9.1
/Q1_B: Q1.2 (B), R4.2, R5.1
/Q1_C: Q1.3 (C), R6.2
/Q2_B: Q2.2 (B), R9.2, R10.1
/Q2_C: Q2.3 (C), R11.1
/RESET: IC1.1 (RESET), R1.2
/SENSE: C4.1, IC1.2 (PB3), R2.2, R3.1, Z1.1 (K)
/STOCK_HIGH: D1.2 (A), J1.2, R2.1
/STOCK_LOW: D2.2 (A), J1.1
/VIN: C1.1, C2.1, D1.1 (K), D2.1 (K), R14.1, TVS1.1 (K), U1.3 (IN)
BATT: J4.1, M1.3 (S), M2.3 (S), R7.2, R12.2
GND: C1.2, C2.2, C3.1, C4.2, C5.2, IC1.4 (GND), J1.3, J2.3, J4.2, Q1.1 (E), Q2.1 (E), R3.2, R5.2, R10.2, R14.2, TVS1.2 (A), U1.2 (GND), Z1.2 (A)

Notes on the sheet:
4. 近燈通道：PB4 → R9 → Q2 導通 → M2 閘極被拉低 → M2 導通，電瓶電流經 M2 到近燈
1. 電源：原車近燈／遠燈線經 D2／D1 合併成 VIN（熄火就斷電）→ 78L05 穩壓成 5V
看圖方式： ・線連在一起就是相通；有黑點的交叉才相連，沒黑點的交叉不相連 ・▽ 接地符號全部是同一點；5V、BATT 箭頭同名的也都相連 ・線上的小字（SENSE、PB0…）是網路名稱，和 PCB 上的名稱一致 ・PWR_FLAG（菱形旗子）只是告訴 ERC 這裡有電源進來，不是零件
C5：實際焊在 IC 座第 8、4 腳旁（MCU 去耦） J5：外接狀態燈（XH 2P），和板上 LED1 同時亮 PB2（第 7 腳）不接
2. 遠燈偵測：遠燈線 → R2 22k → SENSE，R3 10k 分壓、Z1 5.1V 限壓、C4 濾波 → MCU 第 2 腳（PB3）
R14：C1 的放電電阻（約 3k），斷電後讓 VIN 很快歸零， 下次開機 MCU 才會乾淨重置
3. MCU 與狀態燈
J2：接大燈（遠燈、近燈、燈的地線） J4：接電瓶（經 5A 保險絲）
5. 遠燈通道：PB0 → R4 → Q1 → M1，原理同左

Board: 2 copper layers, 90.0 x 40.0 mm, 34 parts (0 on the bottom side), 21 nets.

File hardware/BOM.md:

# 零件清單

編號對應 [原理圖](kicad/) 與 [洞洞板佈線](perfboard.md)。這份清單是照洞洞板版寫的，PCB 版有幾顆零件規格不同，見 [KiCad 說明](kicad/README.md#pcb-版和洞洞板版的差異)。

## 主要零件

| 編號 | 零件 | 規格 | 數量 | 備註 |
|---|---|---|---|---|
| IC1 | MCU | ATtiny85-20PU（DIP-8） | 1 | 工業級 -40～85°C |
| — | IC 座 | 8 腳 | 1 | 圓孔（機製）座比較耐震 |
| U1 | 穩壓 IC | L7805CV（TO-220） | 1 | 78L05 也可以 |
| M1, M2 | P-MOS | IRF4905（TO-220） | 2 | LED 大燈不需散熱片 |
| Q1, Q2 | NPN | SS8050 或 S8050（TO-92） | 2 | |
| D1, D2 | 蕭特基二極體 | 1N5819 | 2 | 1N4007 也可以 |
| TVS | TVS 二極體 | SMBJ18A（單向） | 1 | 不要選 CA（雙向）；插件可用 1.5KE20A/22A 或 P6KE20A/22A |
| Z1 | 稽納二極體 | 1N4733A（5.1V 1W） | 1 | |
| LED1 | LED | 3mm | 1 | 想接兩顆，見下方說明 |

## 電阻（1/4W）

| 編號 | 阻值 | 數量 | 用途 |
|---|---|---|---|
| R2 | 22k | 1 | 遠燈偵測分壓 |
| R1, R3, R5, R7, R10, R12 | 10k | 6 | 重置上拉、偵測分壓、基極下拉、閘極上拉 |
| R6, R11 | 4.7k | 2 | 閘極驅動 |
| R4, R9, R13 | 1k | 3 | NPN 基極、狀態燈限流 |
| **R14** | **2.2k** | 1 | **C1 放電電阻**（兩顆 4.7k 並聯也可以） |

## 電容

| 編號 | 規格 | 數量 | 用途 |
|---|---|---|---|
| C1 | 1000µF 25V 電解（105°C） | 1 | 儲能，切換遠近燈的瞬間撐住 MCU（470µF 也夠） |
| C2, C3, C4, **C5** | 104（100nF）陶瓷或薄膜 | 4 | C5 **直接焊在 IC 座第 8、4 腳之間** |

## 其他

- 洞洞板 7×9cm（26×31 孔）
- 保險絲座 + 5A 保險絲（裝在電瓶正極附近）
- 電線：電瓶與燈的線 1.25mm²，訊號線 0.5mm²
- 原車規格大燈公母插頭各一組
- 燒錄器 USBasp（見 [燒錄說明](../docs/programming.md)）

## 狀態燈想接兩顆

兩顆 LED **並聯，每顆各配一個電阻**，正極接 5V、負極經電阻接 PB1。不要串聯（白光要 6V 以上，5V 點不亮），也不要兩顆共用一個電阻。

| 每顆電阻 | 白／藍光每顆電流 | 兩顆合計 |
|---|---|---|
| 1k | 約 2mA | 約 4mA |
| 470Ω | 約 4mA | 約 8mA |
| 330Ω | 約 6mA | 約 12mA |

ATtiny85 每支腳建議不超過 20mA，電阻不要低於 330Ω。

## Code that names these connections

File firmware/headlight_toggle/headlight_toggle.ino:

// 機車大燈控制器（強光線組版，ATtiny85，ATTinyCore）
// 燈的電源：電瓶 +12V 經保險絲 → 兩顆 P-MOS → 燈
// 原車近燈、遠燈線：只當訊號，並經二極體供電給 MCU（熄火就斷電）
//
// 上電預設：近燈關
// 切遠燈約 2 秒 → 遠燈閃一下提示 → 立即切回近燈 → 近燈 開/關 切換
// 閃完拖太久才切回 → 視為正常使用遠燈，不切換
//
// 狀態燈（板上 LED，接 PB1）：
//   開機閃 1 下：正常開機
//   開機閃 3 下：上次是被看門狗重啟（雜訊干擾），近燈狀態會自動恢復
//   恆亮 / 不亮：近燈開 / 近燈關
//   快閃：提示閃燈後的確認時間，這時切回近燈就會切換

#include <avr/wdt.h>

const uint8_t PIN_HIGH_SENSE = A3;  // PB3：原車遠燈線（22k/10k 分壓）
const uint8_t PIN_LOW_DRIVE  = 4;   // PB4：近燈 MOSFET
const uint8_t PIN_HIGH_DRIVE = 0;   // PB0：遠燈 MOSFET
const uint8_t PIN_LED        = 1;   // PB1：狀態燈（LED 正極接 5V，輸出 LOW 才亮）
const uint8_t PIN_SPARE      = 2;   // PB2：保留

// 分壓 22k/10k，VCC 5V 當參考：ADC = 車電壓 × 10/32 ÷ 5 × 1023
const int ADC_ON  = 576;   // 約 9V 以上才算遠燈開
const int ADC_OFF = 384;   // 約 6V 以下才算遠燈關，中間維持原狀態

const unsigned long HOLD_MS     = 2000;  // 按住多久閃提示
const unsigned long CONFIRM_MS  = 800;   // 閃完後多久內切回才算數
const unsigned long BLINK_MS    = 150;   // 提示閃滅時間
const unsigned long DEBOUNCE_MS = 100;   // 切換判斷用的穩定時間
const unsigned long LED_BOOT_MS = 150;   // 狀態燈開機閃的速度
const unsigned long LED_FAST_MS = 80;    // 狀態燈快閃的速度

// 遠燈時近燈是否也亮（遠近同亮）
const bool LOW_WITH_HIGH = false;

// 這幾個變數放在 .noinit，看門狗重啟時不會被清掉，斷電才會消失
const uint8_t MAGIC = 0xA5;
uint8_t resetFlags __attribute__((section(".noinit")));
uint8_t savedLow   __attribute__((section(".noinit")));
uint8_t savedMagic __attribute__((section(".noinit")));

// 開機最早階段：記下重置原因，並關掉看門狗，否則會一直重開機
void wdt_init(void) __attribute__((naked, used, section(".init3")));
void wdt_init(void) { resetFlags = MCUSR; MCUSR = 0; wdt_disable(); }

bool lowOn = false;
bool senseState = false;   // 遲滯判斷後的遠燈狀態（燈直接跟這個，反應快）
bool highStable = false;   // 再經防彈跳（切換判斷用）
bool highLast = false;
bool blinked = false;
unsigned long lastChange = 0;
unsigned long highStart = 0;
unsigned long blinkTime = 0;
uint8_t bootBlinks = 1;

void setup() {
  digitalWrite(PIN_LED, HIGH);          // 先寫 HIGH 再設輸出，開機不會亂閃
  pinMode(PIN_LED, OUTPUT);
  pinMode(PIN_LOW_DRIVE, OUTPUT);
  pinMode(PIN_HIGH_DRIVE, OUTPUT);
  pinMode(PIN_SPARE, INPUT_PULLUP);     // 沒用到的腳拉高，比較不吃雜訊
  digitalWrite(PIN_HIGH_DRIVE, LOW);
  digitalWrite(PIN_LOW_DRIVE, LOW);

  bool wdtReset = resetFlags & (1 << WDRF);
  if (wdtReset && savedMagic == MAGIC) lowOn = savedLow;   // 騎車中被重啟，近燈維持原狀
  savedLow = lowOn;
  savedMagic = MAGIC;
  bootBlinks = wdtReset ? 3 : 1;

  wdt_enable(WDTO_500MS);               // 當機 0.5 秒自動重啟
}

void updateLed(unsigned long now) {
  bool on;
  if (now < bootBlinks * 2 * LED_BOOT_MS) {
    on = (now / LED_BOOT_MS) % 2 == 0;                    // 開機閃 1 或 3 下
  } else if (highStable && blinked && now - blinkTime <= CONFIRM_MS) {
    on = (now / LED_FAST_MS) % 2 == 0;                    // 現在切回近燈就會切換
  } else {
    on = lowOn;
  }
  digitalWrite(PIN_LED, on ? LOW : HIGH);
}

void loop() {
  wdt_reset();

  int adc = analogRead(PIN_HIGH_SENSE);
  if (adc > ADC_ON)  senseState = true;
  if (adc < ADC_OFF) senseState = false;

  unsigned long now = millis();

  if (senseState != highLast) {
    highLast = senseState;
    lastChange = now;
  }

  if (now - lastChange >= DEBOUNCE_MS && senseState != highStable) {
    highStable = senseState;

    if (highStable) {
      highStart = now;                  // 切入遠燈
      blinked = false;
    } else if (blinked && now - blinkTime <= CONFIRM_MS) {
      lowOn = !lowOn;                   // 提示後立即切回 → 切換
      savedLow = lowOn;
    }
  }

  // 遠燈持續到 2 秒 → 閃一下提示
  if (highStable && !blinked && now - highStart >= HOLD_MS) {
    digitalWrite(PIN_HIGH_DRIVE, LOW);
    delay(BLINK_MS);
    blinked = true;
    blinkTime = millis();
  }

  // 輸出：遠燈跟著開關走；近燈看切換狀態，開遠燈時預設熄近燈
  bool highOut = senseState;
  bool lowOut  = lowOn && (LOW_WITH_HIGH || !senseState);
  digitalWrite(PIN_HIGH_DRIVE, highOut ? HIGH : LOW);
  digitalWrite(PIN_LOW_DRIVE,  lowOut  ? HIGH : LOW);
  updateLed(millis());
}
